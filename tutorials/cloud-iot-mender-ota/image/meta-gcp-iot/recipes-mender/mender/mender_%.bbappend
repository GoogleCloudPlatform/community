require mender-gcp-iot.inc
